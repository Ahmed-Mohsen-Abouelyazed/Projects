# Keil uVision project Home_Automation_AI.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Home_Automation_AI +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Home_Automation_AI.c
